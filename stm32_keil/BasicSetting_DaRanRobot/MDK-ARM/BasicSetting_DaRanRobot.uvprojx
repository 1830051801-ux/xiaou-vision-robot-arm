# Keil uVision project BasicSetting_DaRanRobot.uvprojx, settings and files
target BasicSetting_DaRanRobot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BasicSetting_DaRanRobot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM32_THREAD_SAFE_STRATEGY=2
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\RTT_RTOS;..\RTT_RTOS\include;..\RTT_RTOS\cortex-m4;..\..\RTT_RTOS\src;..\Device\src;..\Device\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s armlib_lock_glue.c
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dma.c iwdg.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c app_threads.c led.c watchdog.c arm_kinematics.c comm_protocol.c trajectory_planner.c servo.c telemetry.c grasp_sequence.c monitor.c calibration.c sys_status.c
    ../Inc/: app_threads.h servo.h grasp_sequence.h monitor.h calib_defaults.h calibration.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_tim_ex.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Device
    ../Device/src/: DrEmpower_can.c
    ../Device/inc/: DrEmpower_can.h
  group RTOS
    ../RTT_RTOS/: board.c rtconfig.h
    ../RTT_RTOS/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../RTT_RTOS/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtm.h rtservice.h rtthread.h
    ../RTT_RTOS/cortex-m4/: context_rvds.S cpuport.c
software components: CMSIS:CORE 4.3.0
